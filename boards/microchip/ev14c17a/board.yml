## boards/microchip/ev14c17a/board.yml
```yaml
board:
  name: ev14c17a
  full_name: IGAT Evaluation Kit
  vendor: atmel
  socs:
    - name: same51j20a
```
